# IAR project SRC_Type_C_DemoDRP.ewp, settings and files
configuration SRC_Type_C_DemoDRP (ARM, debug)
  General.OGChipSelectEditMenu: STM32G071RB ST STM32G071RB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 6
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; USBPD_PORT_COUNT=1; _RTOS; _DRP; _TRACE; _GUI_INTERFACE; USBPDCORE_LIB_PD3_FULL; TCPP0203_SUPPORT; USE_HAL_DRIVER; STM32G071xx
  ICCARM.CCIncludePath2: ../Core/Inc; ../TCPP/App; ../TCPP/Target; ../TCPP; ../USBPD/App; ../USBPD/Target; ../Drivers/STM32G0xx_HAL_Driver/Inc; ../Drivers/STM32G0xx_HAL_Driver/Inc/Legacy; ../Utilities/GUI_INTERFACE; ../Utilities/TRACER_EMB; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM0; ../Middlewares/ST/STM32_USBPD_Library/Core/inc; ../Middlewares/ST/STM32_USBPD_Library/Devices/STM32G0XX/inc; ../Drivers/CMSIS/Device/ST/STM32G0xx/Include; ../Drivers/CMSIS/Include; ../Drivers/BSP/X-NUCLEO-DRP1M1; ../Drivers/BSP/Components/tcpp0203
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: SRC_Type_C_DemoDRP.hex
  ILINK.IlinkOutputFile: SRC_Type_C_DemoDRP.out
  ILINK.IlinkIcfFile: stm32g071xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32g071xx.s
  group Application/User/Core
    ../Core/Src/: main.c app_freertos.c stm32g0xx_it.c stm32g0xx_hal_msp.c
  group Application/User/USBPD/Target
    ../USBPD/Target/: usbpd_dpm_user.c usbpd_pwr_user.c usbpd_vdm_user.c
  group Application/User/USBPD/App
    ../USBPD/App/: usbpd.c usbpd_pwr_if.c usbpd_dpm_core.c
  group Application/User/TCPP/App
    ../TCPP/App/: app_tcpp.c
  group Drivers/STM32G0xx_HAL_Driver
    ../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal_adc.c stm32g0xx_hal_adc_ex.c stm32g0xx_ll_adc.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_ll_rcc.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_cortex.c stm32g0xx_hal.c stm32g0xx_hal_exti.c stm32g0xx_ll_utils.c stm32g0xx_ll_exti.c stm32g0xx_hal_i2c.c stm32g0xx_hal_i2c_ex.c stm32g0xx_hal_uart.c stm32g0xx_hal_uart_ex.c stm32g0xx_ll_usart.c stm32g0xx_ll_lpuart.c stm32g0xx_ll_ucpd.c stm32g0xx_ll_gpio.c stm32g0xx_ll_dma.c stm32g0xx_ll_tim.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g0xx.c
  group Drivers/BSP/X-NUCLEO-DRP1M1
    ../Drivers/BSP/X-NUCLEO-DRP1M1/: drp1m1_bus.c drp1m1_usbpd_pwr.c
  group Drivers/BSP/Components
    ../Drivers/BSP/Components/tcpp0203/: tcpp0203.c tcpp0203_reg.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM0/: port.c portasm.s
  group Middlewares/USBPD
    ../Middlewares/ST/STM32_USBPD_Library/Core/lib/: USBPDCORE_PD3_FULL_CM0PLUS_wc32.a
    ../Middlewares/ST/STM32_USBPD_Library/Core/src/: usbpd_trace.c
    ../Middlewares/ST/STM32_USBPD_Library/Devices/STM32G0XX/src/: usbpd_cad_hw_if.c usbpd_hw.c usbpd_hw_if_it.c usbpd_phy.c usbpd_phy_hw_if.c usbpd_pwr_hw_if.c usbpd_timersserver.c
  group Utilities
    ../Utilities/GUI_INTERFACE/: data_struct_tlv.c bsp_gui.c gui_api.c
    ../Utilities/TRACER_EMB/: tracer_emb.c tracer_emb_hw.c
